# Keil uVision project BalaPi_stm32f4.uvproj, settings and files
target balaPi (ARM-ADS)
  device: STM32F407VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: SENSE +hex
  c flags: OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F4XX, ARM_MATH_CM4,
  c include: ..\inc;..\_Code_;..\_Code_\DEV;..\_Code_\Tools;..\_Code_\Timing;..\_Code_\Commnunication;..\_Code_\Control;..\_Code_\Sensor;..\_Code_\Storage;..\_Code_\User;..\_Code_\Matrix;..\_Code_\DEV\FATFS;..\_Code_\Sensor\Filter
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../_Code_/User/: main.c RGB.c Timing_Manage.c Button.c Voltage_FB.c
  group Filter
    ../_Code_/Sensor/Filter/: EKF_DCM.c AHRS.c Algorithm.c Computation.c Adaptive.c
  group Sensor
    ../_Code_/Sensor/: SENSOR_DATA.c HMC5883L.c MPU6050.c Calibration.c
  group Communication
    ../_Code_/Commnunication/: Serial_Link.c Serial_Link_string.c
  group Storage
    ../_Code_/Storage/: EEPROM.c SDCARD.c Parameter.c
  group DEV Library
    ../_Code_/DEV/: Dev_I2C.c Dev_USART.c Dev_TIMER.c Dev_SDIO.c
    ../_Code_/DEV/FATFS/: diskio.c ff.c
  group Tools
    ../_Code_/Matrix/: arm_mat_init_f32.c arm_mat_mult_f32.c arm_mat_scale_f32.c arm_mat_sub_f32.c arm_mat_trans_f32.c arm_mat_inverse_f32.c
  group Peripheral Library
    ../src/: stm32f4xx_syscfg.c misc.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_sdio.c
  group System
    ./: startup_stm32f4xx.s
    ../_Code_/: system_stm32f4xx.c
